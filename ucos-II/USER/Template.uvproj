# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\CONFIG;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\TOUCH;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\UGUI;..\MALLOC;..\APP;..\TEXT;..\FATFS\src;..\FATFS\exfuns;..\HARDWARE\SPI_FLASH;..\HARDWARE\SPI;..\HARDWARE\SD;..\USMART;..\PICTURE;..\USB\CONFIG;..\USB\LIB;..\USB\UsbHidPrintf
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group UCOSII-CORE
    ../uCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../uCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group UCOSII-CONFIG
    ../uCOSII/CONFIG/: includes.h os_cfg.h
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TOUCH/: ctiic.c ott2001a.c touch.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SPI_FLASH/: spi_flash.c
  group UGUI
    ../UGUI/: button.c gui.c
  group MALLOC
    ../MALLOC/: malloc.c
  group APP
    ../APP/: main_ui.c common.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_scsi.c
  group USB_LIB
    ../USB/LIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_HID_PRINTF
    ../USB/UsbHidPrintf/: usb_hid_printf.c
